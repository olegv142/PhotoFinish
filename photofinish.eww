<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\finish.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\start.ewp</path>
  </project>
  <batchBuild/>
</workspace>


